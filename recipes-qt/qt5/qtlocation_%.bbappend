PACKAGECONFIG = "geoservices_osm geoservices_itemsoverlay"
