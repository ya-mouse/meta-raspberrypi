PACKAGECONFIG_DISTRO = "icu"
PACKAGECONFIG:append = "gif"
