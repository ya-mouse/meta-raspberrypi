CFLAGS += "-Wno-error=format-security"
